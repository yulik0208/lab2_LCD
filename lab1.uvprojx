# Keil uVision project lab1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\libs;.\CMSIS\Device\ST\STM32F4xx\Include;.\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_exti.c
    ./: main.h LCD.h LCD.c
    C:/Users/hp/Downloads/Telegram Desktop/: stm32f4xx_rng.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.6.2
